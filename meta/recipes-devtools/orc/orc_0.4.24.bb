require orc.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "9e793ec34c0e20339659dd4bbbf62135"
SRC_URI[sha256sum] = "338cd493b5247300149821c6312bdf7422a3593ae98691fc75d7e4fe727bd39b"
